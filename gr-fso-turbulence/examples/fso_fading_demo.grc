options:
  parameters:
    description: Sine tone through a Gamma-Gamma FSO fading channel, viewed on QT GUI time and frequency sinks.
    generate_options: qt_gui
    id: fso_fading_demo
    output_language: python
    title: FSO Gamma-Gamma Fading Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fso_turbulence_fso_fading_channel_0
  id: fso_turbulence_fso_fading_channel
  parameters:
    C2n: '1e-15'
    coherence_samples: '1000'
    comment: Moderate turbulence, 1 km link. coherence_samples = samp_rate x 1 ms; correlated windows (tau_large 100 ms, tau_small 10 ms).
    distance: '1000.0'
    sample_rate: samp_rate
    seed: None
    tau_large: '100e-3'
    tau_small: '10e-3'
    wavelength: '1550e-9'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Faded signal (time)"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Faded signal (freq)"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', fso_turbulence_fso_fading_channel_0, '0']
- [fso_turbulence_fso_fading_channel_0, '0', qtgui_time_sink_x_0, '0']
- [fso_turbulence_fso_fading_channel_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
